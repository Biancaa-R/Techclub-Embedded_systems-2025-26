# Keil uVision project nested.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: nested
  c flags: Optim=1
  group Source Group 1
    ./: nested.S
